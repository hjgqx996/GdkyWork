# IAR project project.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F448 MSP430F448
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ..\..\components\usrlibc; ..\..\components\elog\inc; ..\..\sources; ..\..\sources\app; ..\..\sources\app\record; ..\..\sources\app\nb-iot\inc; ..\..\sources\app\nb-iot\inc\pt; ..\..\sources\bsp; ..\..\sources\bsp\msp430x44x
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f448.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group APP
    ../../sources/app/: app.c
    ../../sources/: main.c
  group APP/NB-IoT
    ../../sources/app/nb-iot/src/: nb.c nb_app.c nb_buffer.c nb_parser.c nb_threads.c
  group APP/NB-IoT/port
    ../../sources/app/nb-iot/port/: nb_hw_msp430x44x.c nb_os_empty.c
  group APP/Record
    ../../sources/app/record/: record.c record_app.c record_hw.c record_tbl.c
  group BSP
    ../../sources/bsp/: bsp.c cld1712syu.c HDC1080.c key.c lcd.c paramConfig.c PowerManage.c systick.c systime.c TemperatureMeasure.c
  group BSP/msp430x44x
    ../../sources/bsp/msp430x44x/: analogio.c digitio.c flash.c fm24clxx.c system_msp430x44x.c usart0.c usart1.c
  group Components/elog
    ../../components/elog/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Components/usrlibc
    ../../components/usrlibc/: libcheck.c libmisc.c libstdc.c
