# Keil uVision project project.uvprojx, settings and files
target Flash Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, USE_FULL_ASSERT
  c include: ..\..\components;..\..\components\usrlibc;..\..\components\cpulibs\CMSIS\Include;..\..\components\cpulibs\STM32F4xx_StdPeriph_Driver\;..\..\components\cpulibs\STM32F4xx_StdPeriph_Driver\inc;..\..\components\rtos\FreeRTOS\;..\..\components\rtos\FreeRTOS\FreeRTOS\Source\include;..\..\components\rtos\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\components\rtos\FreeRTOS\FreeRTOS\FreeRTOS-Plus\Source\FreeRTOS-Plus-Trace\Include;..\..\components\filesystem\Reliance-Edge;..\..\components\filesystem\Reliance-Edge\include;..\..\components\filesystem\Reliance-Edge\os\freertos\include;..\..\components\filesystem\Reliance-Edge\core\include;..\..\components\ethernet\CycloneTCP;..\..\components\ethernet\CycloneTCP\common;..\..\components\ethernet\CycloneTCP\cyclone_tcp;..\..\components\gui\STemWin\Include;..\..\components\gui\STemWin\Config;..\..\components\gui\STemWin\Driver;..\..\components\gui\STemWin\Application;..\..\sources;..\..\sources\app;..\..\sources\app\record;..\..\sources\app\elog\inc;..\..\sources\app\elog\port\RTT;..\..\sources\bsp;..\..\sources\bsp\stm32f40x;..\..\sources\bsp\sfud\inc;..\..\sources\bsp\nand
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../../Sources/: main.c
    ../../Sources/app/: app.c
    ../../sources/app/: app_hook.c cmdproc.c meter_power.c combus.c dtu_app.c dtu_buffer.c net_app.c
    ../../sources/app/record/: record_app.c record.c record_tbl.c record_hw.c
    ../../components/usrlibc/: libstdc.c libmisc.c libcheck.c
  group BSP
    ../../sources/bsp/: bsp.c
    ../../sources/bsp/stm32f40x/: systime.c led.c key.c pcf8583.c fm24clxx.c s25fl_flash.c sdmmc_spi .c wtc040g.c usart1.c rs485.c usart3.c uart4.c mbus.c usart6.c stm32f4xx_it.c
    ../../sources/bsp/sfud/src/: sfud.c sfud_sfdp.c
    ../../sources/bsp/sfud/port/: sfud_port_stm32f4.c
    ../../sources/bsp/nand/: nand.c nandftl.c nandhal.c nandhw_s25fl164k.c
  group ELOG
    ../../sources/app/elog/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../../sources/app/elog/port/: elog_port_freertos.c
    ../../sources/app/elog/port/RTT/: SEGGER_RTT.c
  group GUI
    ../../components/gui/STemWin/Driver/: lcd12864.c GUIDRV.c
    ../../components/gui/STemWin/Config/: GUIConf.c LCDConf.c
    ../../components/gui/STemWin/GUI_X/: GUI_X_FreeRTOS.c
    ../../components/gui/STemWin/Lib/: STemWin540_CM4_Keil.lib
    ../../components/gui/STemWin/Application/res/: ST12.c gdkelogo40.c building24.c temp24.c config24.c
    ../../components/gui/STemWin/Application/: gui_string.c MainTask.c MainDLG.c MenuIcoDLG.c PowerMeterCycleDLG.c PowerMeterInstDLG.c TempCtrlCycleDLG.c TempCtrlInstDLG.c SystemDLG.c
  group RTOS
    ../../components/rtos/FreeRTOS/FreeRTOS/Source/: list.c queue.c tasks.c croutine.c timers.c event_groups.c
    ../../components/rtos/FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../components/rtos/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Ethernet
    ../../sources/app/: res.c
    ../../components/ethernet/CycloneTCP/common/: str.c path.c debug.c date_time.c cpu_endian.c resource_manager.c os_port_freertos.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/core/: ethernet.c ethernet_misc.c ip.c net.c net_mem.c nic.c ping.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c dhcp_server.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/ipv4/: arp.c auto_ip.c icmp.c igmp.c ipv4.c ipv4_frag.c ipv4_misc.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/drivers/phy/: dm9161_driver.c
    ../../components/ethernet/CycloneTCP/cyclone_tcp/drivers/mac/: stm32f4x7_eth_driver.c
  group FileSystem
    ../../components/filesystem/Reliance-Edge/core/driver/: blockio.c buffer.c core.c dir.c format.c imap.c imapextern.c imapinline.c inode.c inodedata.c volume.c
    ../../components/filesystem/Reliance-Edge/fse/: fse.c
    ../../components/filesystem/Reliance-Edge/os/freertos/services/: osassert.c osbdev.c osclock.c osmutex.c osoutput.c ostask.c ostimestamp.c
    ../../components/filesystem/Reliance-Edge/posix/: path.c posix.c
    ../../components/filesystem/Reliance-Edge/util/: bitmap.c crc.c endian.c memory.c namelen.c sign.c string.c
    ../../components/filesystem/Reliance-Edge/: redconf.c
  group StdPeriph_Driver
    ../../components/cpulibs/STM32F4xx_StdPeriph_Driver/arm/: startup_stm32f40_41xxx.s
    ../../components/cpulibs/STM32F4xx_StdPeriph_Driver/: system_stm32f4xx.c
    ../../components/cpulibs/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_crc.c stm32f4xx_rng.c stm32f4xx_iwdg.c stm32f4xx_flash.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_qspi.c stm32f4xx_usart.c
  group Doc
    ../../: ChangeLog.txt Directory.txt Download.txt
    ./: readme
target Flash Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
