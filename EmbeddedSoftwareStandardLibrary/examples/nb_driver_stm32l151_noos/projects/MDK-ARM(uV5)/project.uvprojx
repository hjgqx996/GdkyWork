# Keil uVision project project.uvprojx, settings and files
target Flash Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\..\..\..\components;..\..\..\..\components\usrlibc;..\..\..\..\components\cpulibs\CMSIS\Include;..\..\..\..\components\cpulibs\STM32L1xx_StdPeriph_Driver\;..\..\..\..\components\cpulibs\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\components\rtos\FreeRTOS\FreeRTOS\Source\include;..\..\..\..\components\rtos\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\components\rtos\FreeRTOS\FreeRTOS\FreeRTOS-Plus\Source\FreeRTOS-Plus-Trace\Include;..\..\sources;..\..\sources\app;..\..\sources\bsp;..\..\..\..\sources\app\elog\inc;..\..\..\..\sources\app\elog\port\RTT;..\..\..\..\sources\app\nb-iot\inc;..\..\..\..\sources\bsp\stm32l1xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../../Sources/: main.c
    ../../sources/app/: app.c
    ../../../../components/usrlibc/: libcheck.c libmisc.c libstdc.c
  group BSP
    ../../sources/bsp/: bsp.c systime.c
    ../../../../sources/bsp/stm32l1xx/: led.c key.c rtc.c usart2.c mbus.c rs485.c fm24clxx.c stm32l1xx_it.c
  group NB-IoT
    ../../../../sources/app/nb-iot/src/: nb_app.c nb.c nb_threads.c nb_parser.c nb_buffer.c
    ../../../../sources/app/nb-iot/port/: nb_os_freertos.c nb_hw_stm32l15x.c
  group ELog
    ../../../../sources/app/elog/src/: elog.c elog_async.c elog_utils.c
    ../../../../sources/app/elog/port/: elog_port_freertos.c
    ../../../../sources/app/elog/port/RTT/: SEGGER_RTT.c
  group STM32L1xx_StdPeriph_Driver
    ../../../../components/cpulibs/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_syscfg.c stm32l1xx_rcc.c stm32l1xx_pwr.c stm32l1xx_rtc.c stm32l1xx_tim.c stm32l1xx_iwdg.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_exti.c stm32l1xx_usart.c
    ../../../../components/cpulibs/STM32L1xx_StdPeriph_Driver/: system_stm32l1xx.c
    ../../../../components/cpulibs/STM32L1xx_StdPeriph_Driver/arm/: startup_stm32l1xx_md.s
  group Doc
    ./: readme
target Flash Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_FULL_ASSERT
  c include: ..\..\..\..\components;..\..\..\..\components\usrlibc;..\..\..\..\components\cpulibs\CMSIS\Include;..\..\..\..\components\cpulibs\STM32L1xx_StdPeriph_Driver\;..\..\..\..\components\cpulibs\STM32L1xx_StdPeriph_Driver\inc;..\..\sources;..\..\sources\app;..\..\sources\bsp;..\..\..\..\sources\app\elog\inc;..\..\..\..\sources\app\elog\port\RTT;..\..\..\..\sources\app\nb-iot\inc;..\..\..\..\sources\bsp\stm32l1xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
